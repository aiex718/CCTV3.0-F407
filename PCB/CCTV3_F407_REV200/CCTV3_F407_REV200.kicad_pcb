# Repository aiex718/CCTV3.0-F407 (continued)

## KiCad design PCB/CCTV3_F407_REV100/CCTV3_F407_REV100.kicad_pcb (continued)

Parts:
C25: 4.7uF; C0603; Voltage 16V; LCSC Part TBD
C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37: 100nF; C0603; Voltage 50V; LCSC Part TBD
C38, C39, C42: 100nF; C0603; Voltage 25V; LCSC Part TBD
C40, C41: 15pF; C0603; Voltage 16V; LCSC Part TBD
C43, C44: 2.2uF; C0603; Voltage 16V; LCSC Part TBD
C45, C46: 15pF; C0603; Voltage 50V; LCSC Part TBD
CN1: VBAT; CONN-TH_0530470210; LCSC Part C114130
D4: BAT54C; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; LCSC Part C37704
J3: SWD; PinHeader_1x04_P2.54mm_Vertical
J4: UART; PinHeader_1x04_P2.54mm_Vertical
J5: FireDAP-SWD; PinHeader_1x05_P2.54mm_Vertical
J6: Conn_Boot; PinHeader_2x03_P2.54mm_Vertical
R10, R16, R17: 10k; R0603; LCSC Part TBD
R11, R12: 100k; R0603; LCSC Part TBD
R13: NC; R0603; LCSC Part TBD
R14, R15, R18: 0R; R0603; LCSC Part TBD
U7: STM32F407ZETx; LQFP-144_20x20mm_P0.5mm
X1: 32.768k; FC-135R_L3.2-W1.5; LCSC Part C32346
X2: 25M; OSC-SMD_4P-L3.2-W2.5-BL; LCSC Part C9006

Connections:
+2V5: C39.1, U7.32 (VREF+); also elsewhere on the board
+3.3V: C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, D4.1 (A), J6.1, J6.2, R10.1, R14.2, R15.2, R18.2, U7.17 (VDD), U7.30 (VDD), U7.39 (VDD), U7.52 (VDD), U7.62 (VDD), U7.72 (VDD), U7.84 (VDD), U7.95 (VDD), U7.108 (VDD), U7.121 (VDD), U7.131 (VDD), U7.144 (VDD); also elsewhere on the board
BOOT0: R11.1, R16.2, U7.138 (BOOT0)
BOOT1: R12.1, R17.1, U7.48 (PB2)
GND: C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C40.1, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, CN1.1, J3.4, J4.4, J5.3, J6.5, J6.6, R11.2, R12.2, R13.2, U7.16 (VSS), U7.38 (VSS), U7.51 (VSS), U7.61 (VSS), U7.83 (VSS), U7.94 (VSS), U7.107 (VSS), U7.120 (VSS), U7.130 (VSS), X2.2 (GND), X2.4 (GND); also elsewhere on the board
MCO1: U7.100 (PA8); also elsewhere on the board
NRST: J5.1, U7.25 (NRST); also elsewhere on the board
unnamed: C40.2, U7.8 (PC14), X1.1
unnamed: C41.1, U7.9 (PC15), X1.2
unnamed: C42.1, D4.3 (K), U7.6 (VBAT)
unnamed: C43.1, U7.71 (VCAP_1)
unnamed: C44.1, U7.106 (VCAP_2)
unnamed: C45.1, U7.23 (PH0), X2.1 (OSC1)
unnamed: C46.1, U7.24 (PH1), X2.3 (OSC2)
unnamed: CN1.2, D4.2 (A)
unnamed: J3.1, R14.1
unnamed: J4.1, R15.1
unnamed: J5.5, R18.1
unnamed: J6.3, R16.1
unnamed: J6.4, R17.2
PA0: U7.34 (PA0); also elsewhere on the board
PA1: U7.35 (PA1); also elsewhere on the board
PA2: U7.36 (PA2); also elsewhere on the board
PA3: U7.13 (PF3), U7.37 (PA3); also elsewhere on the board
PA4: U7.40 (PA4); also elsewhere on the board
PA5: U7.41 (PA5)
PA6: U7.42 (PA6); also elsewhere on the board
PA7: U7.43 (PA7); also elsewhere on the board
PA9: U7.101 (PA9); also elsewhere on the board
PA10: U7.102 (PA10); also elsewhere on the board
PA11: U7.103 (PA11); also elsewhere on the board
PA12: U7.104 (PA12); also elsewhere on the board
PA13: J3.2, J5.4, U7.105 (PA13)
PA14: J3.3, J5.2, U7.109 (PA14)
PA15: U7.110 (PA15)
PB0: U7.46 (PB0)
PB1: U7.47 (PB1)
PB3: U7.133 (PB3)
PB4: U7.134 (PB4)
PB5: U7.135 (PB5)
PB6: U7.136 (PB6); also elsewhere on the board
PB7: U7.137 (PB7); also elsewhere on the board
PB8: U7.139 (PB8); also elsewhere on the board
PB9: U7.140 (PB9); also elsewhere on the board
PB10: U7.69 (PB10)
PB11: U7.70 (PB11)
PB12: U7.73 (PB12); also elsewhere on the board
PB13: U7.74 (PB13); also elsewhere on the board
PB14: U7.75 (PB14); also elsewhere on the board
PB15: U7.76 (PB15); also elsewhere on the board
PC0: U7.26 (PC0)
PC1: U7.27 (PC1); also elsewhere on the board
PC2: U7.28 (PC2)
PC3: U7.29 (PC3)
PC4: U7.44 (PC4); also elsewhere on the board
PC5: U7.45 (PC5); also elsewhere on the board
PC6: U7.96 (PC6)
PC7: U7.97 (PC7); also elsewhere on the board
PC8: U7.98 (PC8); also elsewhere on the board
PC9: U7.99 (PC9); also elsewhere on the board
PC10: J4.3, U7.111 (PC10)
PC11: J4.2, U7.112 (PC11)
PC12: U7.113 (PC12)
PC13: U7.7 (PC13)
PD0: U7.114 (PD0); also elsewhere on the board
PD1: U7.115 (PD1); also elsewhere on the board
PD2: U7.116 (PD2)
PD3: U7.117 (PD3)
PD4: U7.118 (PD4); also elsewhere on the board
PD5: U7.119 (PD5); also elsewhere on the board
PD6: U7.122 (PD6)
PD7: U7.123 (PD7)
PD8: U7.77 (PD8); also elsewhere on the board
PD9: U7.78 (PD9); also elsewhere on the board
PD10: U7.79 (PD10); also elsewhere on the board
PD11: U7.80 (PD11); also elsewhere on the board
PD12: U7.81 (PD12); also elsewhere on the board
PD13: U7.82 (PD13)
PD14: U7.85 (PD14); also elsewhere on the board
PD15: U7.86 (PD15); also elsewhere on the board
PDR_ON: R10.2, R13.1, U7.143 (PDR_ON)
PE0: U7.141 (PE0); also elsewhere on the board
PE1: U7.142 (PE1); also elsewhere on the board
PE2: U7.1 (PE2); also elsewhere on the board
PE3: U7.2 (PE3); also elsewhere on the board
PE4: U7.3 (PE4); also elsewhere on the board
PE5: U7.4 (PE5); also elsewhere on the board
PE6: U7.5 (PE6); also elsewhere on the board
PE7: U7.58 (PE7); also elsewhere on the board
PE8: U7.59 (PE8); also elsewhere on the board
PE9: U7.60 (PE9); also elsewhere on the board
PE10: U7.63 (PE10); also elsewhere on the board
PE11: U7.64 (PE11); also elsewhere on the board
PE12: U7.65 (PE12); also elsewhere on the board
PE13: U7.66 (PE13); also elsewhere on the board
PE14: U7.67 (PE14); also elsewhere on the board
PE15: U7.68 (PE15); also elsewhere on the board
PF0: U7.10 (PF0); also elsewhere on the board
PF1: U7.11 (PF1); also elsewhere on the board
PF2: U7.12 (PF2); also elsewhere on the board
PF4: U7.14 (PF4); also elsewhere on the board
PF5: U7.15 (PF5); also elsewhere on the board
PF6: U7.18 (PF6); also elsewhere on the board
PF7: U7.19 (PF7); also elsewhere on the board
PF8: U7.20 (PF8); also elsewhere on the board
PF9: U7.21 (PF9)
PF10: U7.22 (PF10)
PF11: U7.49 (PF11); also elsewhere on the board
PF12: U7.50 (PF12); also elsewhere on the board
PF13: U7.53 (PF13); also elsewhere on the board
PF14: U7.54 (PF14); also elsewhere on the board
PF15: U7.55 (PF15); also elsewhere on the board
PG0: U7.56 (PG0); also elsewhere on the board
PG1: U7.57 (PG1); also elsewhere on the board
PG2: U7.87 (PG2); also elsewhere on the board
PG3: U7.88 (PG3); also elsewhere on the board
PG4: U7.89 (PG4); also elsewhere on the board
PG5: U7.90 (PG5); also elsewhere on the board
PG6: U7.91 (PG6)
PG7: U7.92 (PG7)
PG8: U7.93 (PG8)
PG9: U7.124 (PG9)
PG10: U7.125 (PG10)
PG11: U7.126 (PG11); also elsewhere on the board
PG12: U7.127 (PG12); also elsewhere on the board
PG13: U7.128 (PG13); also elsewhere on the board
PG14: U7.129 (PG14); also elsewhere on the board
PG15: U7.132 (PG15); also elsewhere on the board

Notes on the sheet:
BOOT & DEBUG
MCU STM32F407ZETx

Parts:
C47, C53: 10uF; C0603; Voltage 16V; LCSC Part TBD
C48: 22uF; C0603; Voltage 6.3V; LCSC Part TBD
C49, C56: 4.7uF; C0603; Voltage 16V; LCSC Part TBD
C50, C51, C52, C54, C55, C57, C59, C60: 100nF; C0603; Voltage 50V; LCSC Part TBD
C58: 1uF; C0603; Voltage 50V; LCSC Part TBD
C61: 4.7nF; C0603; Voltage 50V; LCSC Part TBD
CAM1: OV2640_7mm_FPC-05F-24PH20; LCSC Part C2856805
D5: 1N4148W; SOD-123F_L2.7-W1.6-LS3.8-RD; LCSC Part C81598
J7: Conn_4-20mA; PhoenixContact_MSTBA_2,5_3-G_1x03_P5.00mm_Horizontal
L3, L4, L5, L6: 600R; L0603; LCSC Part C1002
R19, R22, R23, R25: 10k; R0603; LCSC Part TBD
R20, R21: 4.7k; R0603; LCSC Part TBD
R24: 1k; R0603; Tolerance 1%; LCSC Part TBD
R26: 5.1k; R0603; Tolerance 1%; LCSC Part TBD
R27: 10K; RES-ADJ-TH_3P-L10.0-W10.0-P2.50-L; LCSC Part C118954
R28: 124k; R0603; Tolerance 1%; LCSC Part TBD
R29: 51R; R0603; LCSC Part TBD
R30: 120R; R0603; Tolerance 0.1%; LCSC Part TBD
TP1: TestPoint_Small; TestPoint_Pad_D1.0mm
U8: IS61WV25616EDBLL-10TLI; TSOP-44_L18.4-W10.2-P0.80-LS11.8-BL; LCSC Part C883296
U9: W25Q128JVSIQTR; SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL; LCSC Part C97521
U10: OP07CDR; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; LCSC Part C7433

Connections:
+1V35: C55.1, C56.1, CAM1.10 (DVDD)
+2V5: R26.2; also elsewhere on the board
+2V8: C52.2, CAM1.11 (DOVDD), L4.1, R20.1, R21.1, R22.1; also elsewhere on the board
+3.3V: C47.1, C60.2, L3.1, R25.1, U9.3 (IO2_~WP), U9.7 (IO3_~RST), U9.8 (VCC); also elsewhere on the board
+12VA: J7.1, L6.1
GND: C47.2, C48.2, C49.2, C50.1, C51.1, C52.1, C55.2, C56.2, C57.1, C60.1, CAM1.15 (DGND), CAM1.25, CAM1.26, L5.1, R23.2, U8.12 (GND), U8.34 (GND), U9.4 (GND); also elsewhere on the board
MCO1: CAM1.13 (XCLK), TP1.1; also elsewhere on the board
unnamed: D5.1 (K), R30.1, U10.3 (IN+)
unnamed: D5.2 (A), J7.2
unnamed: R24.1, R29.2, U10.6 (OUT)
unnamed: R24.2, R26.1, R28.1, U10.2 (IN-)
unnamed: R27.1, U10.8 (OFFSETN2)
unnamed: R27.2, U10.1 (OFFSETN1)
PA3: C61.2, R29.1; also elsewhere on the board
PA4: CAM1.9 (HREF); also elsewhere on the board
PA6: CAM1.17 (PCLK); also elsewhere on the board
PA9: CAM1.19 (D2); also elsewhere on the board
PB6: CAM1.16 (D7); also elsewhere on the board
PB7: CAM1.7 (VSYNC); also elsewhere on the board
PB8: CAM1.5 (SIOC), R21.2; also elsewhere on the board
PB9: CAM1.3 (SIOD), R20.2; also elsewhere on the board
PB12: R25.2, U9.1 (~CS); also elsewhere on the board
PB13: U9.6 (CLK); also elsewhere on the board
PB14: U9.2 (DO); also elsewhere on the board
PB15: U9.5 (DI); also elsewhere on the board
PC7: CAM1.21 (D3); also elsewhere on the board
PC8: CAM1.22 (D4); also elsewhere on the board
PC9: CAM1.20 (D5); also elsewhere on the board
PD0: U8.9 (I/O2); also elsewhere on the board
PD1: U8.10 (I/O3); also elsewhere on the board
PD4: U8.41 (~OE); also elsewhere on the board
PD5: U8.17 (~WE); also elsewhere on the board
PD8: U8.36 (I/O13); also elsewhere on the board
PD9: U8.37 (I/O14); also elsewhere on the board
PD10: U8.38 (I/O15); also elsewhere on the board
PD11: U8.43 (A16); also elsewhere on the board
PD12: U8.44 (A17); also elsewhere on the board
PD14: U8.7 (I/O0); also elsewhere on the board
PD15: U8.8 (I/O1); also elsewhere on the board
PE0: U8.39 (~LB); also elsewhere on the board
PE1: U8.40 (~UB); also elsewhere on the board
PE2: CAM1.8 (PWND), R23.1; also elsewhere on the board
PE3: C57.2, CAM1.6 (~RESET), R22.2; also elsewhere on the board
PE4: CAM1.18 (D6); also elsewhere on the board
PE5: CAM1.14 (D8); also elsewhere on the board
PE6: CAM1.12 (D9); also elsewhere on the board
PE7: U8.13 (I/O4); also elsewhere on the board
PE8: U8.14 (I/O5); also elsewhere on the board
PE9: U8.15 (I/O6); also elsewhere on the board
PE10: U8.16 (I/O7); also elsewhere on the board
PE11: U8.29 (I/O8); also elsewhere on the board
PE12: U8.30 (I/O9); also elsewhere on the board
PE13: U8.31 (I/O10); also elsewhere on the board
PE14: U8.32 (I/O11); also elsewhere on the board
PE15: U8.35 (I/O12); also elsewhere on the board
PF0: U8.1 (A0); also elsewhere on the board
PF1: U8.2 (A1); also elsewhere on the board
PF2: U8.3 (A2); also elsewhere on the board
PF3: U8.4 (A3)
PF4: U8.5 (A4); also elsewhere on the board
PF5: U8.18 (A5); also elsewhere on the board
PF12: U8.19 (A6); also elsewhere on the board
PF13: U8.20 (A7); also elsewhere on the board
PF14: U8.21 (A8); also elsewhere on the board
PF15: U8.22 (A9); also elsewhere on the board
PG0: U8.23 (A10); also elsewhere on the board
PG1: U8.24 (A11); also elsewhere on the board
PG2: U8.25 (A12); also elsewhere on the board
PG3: U8.26 (A13); also elsewhere on the board
PG4: U8.27 (A14); also elsewhere on the board
PG5: U8.42 (A15); also elsewhere on the board
PG12: R19.2, U8.6 (~CE); also elsewhere on the board
VDDF: C48.1, C49.1, C50.2, C51.2, L3.2, R19.1, U8.11 (VDD), U8.33 (VDD)

Notes on the sheet:
4-20ma Receiver
CAMERA
Flash
50Ω等長走線
SRAM

Parts:
C1, C7, C12, C24: 100nF; C0603; Voltage 50V; LCSC Part TBD
C2, C13: 1uF; C0603; Voltage 25V; LCSC Part TBD
C3, C6, C8, C14, C16: 10uF; C0603; Voltage 25V; LCSC Part TBD
C4, C15: 100uF; CAP-SMD_L3.5-W2.8; Voltage 6.3V Tantalum; LCSC Part TBD
C5, C22: 100uF; CP_Radial_D8.0mm_P3.50mm; Voltage 50V; LCSC Part C350209
C9: 100nF; C0603; Voltage 25V; LCSC Part TBD
C10, C20: 1uF; C0603; Voltage 16V; LCSC Part TBD
C11, C17, C19, C21: 10uF; C0603; Voltage 16V; LCSC Part TBD
C18: 22nF; C0603; Voltage 50V; LCSC Part TBD
C23: 10uF; C1206; Voltage 50V; LCSC Part TBD
D1: ZMM10; LL-34_L3.5-W1.5-RD; LCSC Part C707201
D2: ZMM5V6; LL-34_L3.5-W1.5-RD; LCSC Part C8062
D3: SS34; DO-214AC_L4.3-W2.7-LS5.3-RD; LCSC Part C8678
F1, F2, F3: FUSE 0.75A; F1812; Voltage 33V
J1: Jmp_5V; PinHeader_2x01_P2.54mm_Vertical
J2: Jmp_3.3V; PinHeader_2x01_P2.54mm_Vertical
L1: 600R; L0603; LCSC Part C1002
L2: 600R 100Mhz; L0603; LCSC Part C1002
Q1: AO3400A; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; LCSC Part C20917
Q2: AO3401A; SOT-23_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C15127
R1, R2, R3, R7: 4.7k; R0603; LCSC Part TBD
R4, R8: 6.8k; R0603; LCSC Part TBD
R5, R6: 47k; R0603; LCSC Part TBD
R9: 800R; R0805; LCSC Part TBD
U1: AMS1117-5.0; SOT-223_L6.5-W3.5-P2.30-LS7.0-BR; LCSC Part C6187
U2, U4: MT9700; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; LCSC Part C89855
U3: AMS1117-3.3; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR; LCSC Part C6186
U5: RT9193-28GB; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; LCSC Part C56731
U6: CJ431; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; LCSC Part C3113

Connections:
+2V5: C20.2, R9.1, U6.1 (K), U6.2 (R); also elsewhere on the board
+2V8: C17.1, U5.5 (VOUT); also elsewhere on the board
+3.3V: C19.2, L1.1; also elsewhere on the board
+3V3: C9.1, C10.1, C11.1, C16.1, U4.1 (VOUT), U5.1 (VIN), U5.3 (EN)
/POWER/LDO_3.3V: C15.1, J2.1, U3.2 (VOUT), U3.4 (VOUT)
/POWER/LDO_5V: C4.1, Q1.2 (S), U1.2 (VOUT), U1.4 (VOUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C22.2, C23.2, C24.2, D1.2 (A), D2.2 (A), L2.1, R4.2, R5.1, R6.1, R8.2, U1.3 (VIN), U2.2 (GND), U3.1 (GND), U4.2 (GND), U5.2 (GND), U6.3 (A); also elsewhere on the board
unnamed: C5.1, C6.1, C7.1, J1.2, R1.1, U2.5 (VIN)
unnamed: C18.1, U5.4 (BP)
unnamed: D1.1 (K), Q1.1 (G), R2.1, R5.2
unnamed: D2.1 (K), Q2.1 (G), R3.1, R6.2
unnamed: J2.2, R7.1, U4.5 (VIN)
unnamed: R1.2, U2.4 (EN)
unnamed: R4.1, U2.3 (SET)
unnamed: R7.2, U4.4 (EN)
unnamed: R8.1, U4.3 (SET)
VBUS: Q2.3 (D); also elsewhere on the board

Notes on the sheet:
5V Current Limit
2.8V LDO
3.3V 1A
5V LDO
VBUS Switch
VDDA & 2.5V-VREF
3.3V LDO
Ext. Power
5V 1A

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
Board: 4 copper layers, 224 parts (1 on the bottom side), 171 nets, no tracks yet.

## KiCad design PCB/CCTV3_POE_REV100/CCTV3_POE_REV100.kicad_pcb

Parts:
C1, C2, C3, C4: 10pF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
C5, C6, C13, C14, C15, C16: 10nF; C_0603_1608Metric; Voltage 250V; LCSC Part TBD
C7, C17: 1000pF; C_1206_3216Metric; Voltage 2KV; LCSC Part TBD
C8: 220uF; CP_Elec_6.3x7.7; Voltage 25V; LCSC Part C371974
C9, C10: 10uF; C_0805_2012Metric; Voltage 25V; LCSC Part TBD
C11: 10uF; C_0603_1608Metric; Voltage 25V; LCSC Part TBD
C12, C18: 10uF; C_1206_3216Metric; Voltage 50V; LCSC Part TBD
C19: 100nF; C_0603_1608Metric; Voltage 50V; LCSC Part TBD
C20: 47uF; C_1206_3216Metric; Voltage 10V; LCSC Part TBD
C21: 10nF; C_0603_1608Metric; Voltage 50; LCSC Part TBD
C22: 1nF; C_0603_1608Metric; Voltage 50V; LCSC Part TBD
C23: 47pF; C_0603_1608Metric; Voltage 50V; LCSC Part TBD
D1, D2: MB6S; TO-269AA
D3: SMBJ58A; D_SMB; LCSC Part C707476
D4: SMAJ5.0CA; D_SMA; LCSC Part C83324
D5: SS34; D_SMA; LCSC Part C8678
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_Pad
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2: Conn_4-20mA; PhoenixContact_MSTBA_2,5_3-G_1x03_P5.00mm_Horizontal
J3: M12_8P_Horizontal
J4: Jmp_12V; PinHeader_2x01_P2.54mm_Vertical
L1, L2: 100R; L_0805_2012Metric; LCSC Part C1015
L3: HY601742; RJ45-SMD_HY601742; LCSC Part C55684
L4, L6: 600R; L_0603_1608Metric; LCSC Part C1002
L5: SMNR4020-2.2UH; IND-SMD_L4.0-W4.0_SMNR4020; LCSC Part C135262
L7: 33uH; IND-SMD_L6.0-W6.0; LCSC Part C285825
R1, R2, R5, R6, R7, R8: 75R; R_0603_1608Metric; LCSC Part TBD
R3: 4.7k; R_0603_1608Metric; LCSC Part TBD
R4: 6.8k; R_0603_1608Metric; LCSC Part TBD
R9: 330k; R_0603_1608Metric; LCSC Part TBD
R10: 10k; R_0603_1608Metric; LCSC Part TBD
R11: 68k; R_0603_1608Metric; LCSC Part TBD
R12: 2k; R_0603_1608Metric; LCSC Part TBD
R13: 30K; R_0603_1608Metric; LCSC Part TBD
RJ1: R-RJ45S08P-C000; RJ45-TH_R-RJ45S08P-C000; LCSC Part C386764
U1: DP5312_SDAPO
U2: MT9700; SOT-23-5; LCSC Part C89855
U3: TPS54331DR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC Part C9865

Connections:
+5V_POE: C20.1, D4.1, J1.3, L7.2, R10.1
+12V_POE: C12.1, C18.1, J1.4, L1.2, R9.1, U2.1 (VOUT), U3.2 (VIN)
/MGND: C17.1, J3.9, L6.1
/RGND: C7.1, L4.1, RJ1.13 (S), RJ1.14 (S)
/RJ5: C14.1, D2.2, J3.1, J3.7
/RJ7: C13.1, D2.1, J3.2, J3.3
/RJ12_N: J3.4, L3.1
/RJ12_P: J3.6, L3.3
/RJ36_N: J3.8, L3.8
/RJ36_P: J3.5, L3.6
/RXN: C4.1, L3.9, RJ1.6
/RXP: C3.1, L3.11, RJ1.3
/TXN: C1.1, L3.16, RJ1.2
/TXP: C2.1, L3.14, RJ1.1
GND: C1.2, C2.2, C3.2, C4.2, C8.2, C9.2, C10.2, C11.2, C12.2, C18.2, C20.2, C21.1, C23.2, D4.2, D5.2 (A), H1.1, H2.1, H3.1, H4.1, J1.2, L2.2, L4.2, L6.2, R4.2, R11.2, R12.2, R13.2, U1.5 (-VDC), U1.8 (-VDC), U2.2 (GND), U3.7 (GND)
ISEN: J1.1, J2.2
unnamed: C5.1, R1.2
unnamed: C5.2, C6.2, C7.2
unnamed: C6.1, R2.2
unnamed: C8.1, C9.1, L5.1, U1.6 (+VDC)
unnamed: C10.1, J4.1, L5.2
unnamed: C11.1, J4.2, R3.1, U2.5 (VIN)
unnamed: C13.2, R5.1
unnamed: C14.2, R6.1
unnamed: C15.1, D1.1, L3.2
unnamed: C15.2, R7.1
unnamed: C16.1, D1.2, L3.7
unnamed: C16.2, R8.1
unnamed: C17.2, R5.2, R6.2, R7.2, R8.2
unnamed: C19.1, D5.1 (K), L7.1, U3.8 (PH)
unnamed: C19.2, U3.1 (BOOT)
unnamed: C21.2, U3.4 (SS)
unnamed: C22.1, C23.1, U3.6 (COMP)
unnamed: C22.2, R13.1
unnamed: D1.3 (+), D2.3 (+), D3.1 (K), U1.1 (VIN+)
unnamed: D1.4 (-), D2.4 (-), D3.2 (A), U1.2 (VIN-)
unnamed: J2.1, L1.1
unnamed: J2.3, L2.1
unnamed: L3.10, R1.1
unnamed: L3.15, R2.1
unnamed: R3.2, U2.4 (EN)
unnamed: R4.1, U2.3 (SET)
unnamed: R10.2, R12.1, U3.5 (VSENSE)
unnamed: R9.2, R11.1, U3.3 (EN)

Notes on the sheet:
100Ω差動走線
CCTV3_POE_REV100
<- As close as possible ↴
12V 1A
12-24V -> 5V 2A
<-Maximumx distance 15mm->
<-Maximumx distance 25mm->
