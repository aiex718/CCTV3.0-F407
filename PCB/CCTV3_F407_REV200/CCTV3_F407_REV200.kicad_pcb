# Repository aiex718/CCTV3.0-F407

## KiCad design PCB/CCTV3_F407_REV200/CCTV3_F407_REV200.kicad_pcb

Notes on the sheet:
Initial release
PAGE_5
REVISIONS
PAGE_1
PAGE_2
PAGE_3
REV200
${BOARDNAME}
Table of Contents
REV100
Change mcu to F407VETx, remove SRAM
PAGE_6
PAGE_4

Parts:
C53: 1uF; C_0402_1005Metric; Voltage 25V; LCSC Part TBD
C54: 470pF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
C55, C56: 100nF; C_0402_1005Metric; Voltage 6.3V; LCSC Part TBD
C57, C58, C59: 10uF; C_0402_1005Metric; Voltage 6.3V; LCSC Part TBD
C60: 100nF; C_0402_1005Metric; Voltage 16V; LCSC Part TBD
C61, C62, C63, C64: 10pF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
C65: 220nF; C_0402_1005Metric; Voltage 16V; LCSC Part TBD
C66, C67: 15pF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
L9, L10: 600R; L_0603_1608Metric; LCSC Part C1002
R30, R31: 270R; R_0603_1608Metric; LCSC Part TBD
R32, R33, R34, R35: 49.9R; R_0402_1005Metric; Tolerance 1%; LCSC Part TBD
R36: 10k; R_0402_1005Metric; Tolerance 1%; LCSC Part TBD
R37: 12.1k; R_0402_1005Metric; Tolerance 1%; LCSC Part TBD
R38: 33R; R_0603_1608Metric; LCSC Part TBD
R39, R40: 4.7k; R_0603_1608Metric; LCSC Part TBD
RJ1: HY951180A; RJ45-TH_HY951180A; LCSC Part C34677
TV3, TV4: SRV05-4-P-T7; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; LCSC Part C85364
U10: LAN8720A; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
X3: 25M; OSC-SMD_4P-L3.2-W2.5-BL; LCSC Part C9006

Connections:
+3.3V: C58.1, C59.1, C60.1, L9.2, R36.2, U10.9 (VDDIO); also elsewhere on the board
+3.3V_ETH: C55.1, C56.1, C57.1, C65.2, L9.1, R32.1, R33.1, R34.1, R35.1, RJ1.3 (TC), RJ1.5 (RC), U10.1 (VDD2A), U10.19 (VDD1A)
/PHY,Ethernet/LINK: R30.2, R40.2, U10.3 (LED1/REGOFF)
/PHY,Ethernet/SPD: R31.2, R39.2, U10.2 (LED2/nINTSEL)
ETH_CLKIN: C66.1, U10.5 (XTAL1/CLKIN), X3.1 (OSC1); also elsewhere on the board
ETH_CRS_DV: U10.11 (CRS_DV/MODE2); also elsewhere on the board
ETH_MDC: U10.13 (MDC); also elsewhere on the board
ETH_MDIO: U10.12 (MDIO); also elsewhere on the board
ETH_REF_CLK: R38.1; also elsewhere on the board
ETH_RXD0: U10.8 (RXD0/MODE0); also elsewhere on the board
ETH_RXD1: U10.7 (RXD1/MODE1); also elsewhere on the board
ETH_TXD0: U10.17 (TXD0); also elsewhere on the board
ETH_TXD1: U10.18 (TXD1); also elsewhere on the board
ETH_TX_EN: U10.16 (TXEN); also elsewhere on the board
GND: C53.1, C54.1, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.1, C66.2, C67.2, L10.2, R37.1, R39.1, R40.1, RJ1.8 (CHSGND), RJ1.10 (LEDG-), RJ1.11 (LEDY-), TV3.2, TV4.2, U10.25 (VSS), X3.2 (GND), X3.4 (GND); also elsewhere on the board
NRST: U10.15 (RST); also elsewhere on the board
unnamed: C53.2, C54.2, U10.6 (VDDCR)
unnamed: C67.1, U10.4 (XTAL2), X3.3 (OSC2)
unnamed: L10.1, RJ1.13 (SHIELD), RJ1.14 (SHIELD)
unnamed: R30.1, RJ1.9 (LEDG+)
unnamed: R31.1, RJ1.12 (LEDY+)
unnamed: R36.1, U10.10 (RXER/PHYAD0)
unnamed: R37.2, U10.24 (RBIAS)
unnamed: R38.2, U10.14 (INT/REFCLKO)
RX_N: C64.1, R35.2, RJ1.7 (RD-), TV4.6, U10.22 (RXN)
RX_P: C63.1, R34.2, RJ1.6 (RD+), TV4.1, U10.23 (RXP)
TX_N: C62.1, R33.2, RJ1.2 (TD-), TV3.3, U10.20 (TXN)
TX_P: C61.1, R32.2, RJ1.1 (TD+), TV3.4, U10.21 (TXP)

Notes on the sheet:
Ethernet Phy
100Ω差動走線
68Ω等長走線

Parts:
BUZZER1: HNB09A03; BUZ-TH_BD9.0-P5.00-D0.6-FD; LCSC Part C96102
C68, C69: 10uF; C_0603_1608Metric; Voltage 10V; LCSC Part TBD
C70, C75: 100nF; C_0402_1005Metric; Voltage 16V; LCSC Part TBD
C71, C72, C73, C74: 10uF; C_1206_3216Metric; Voltage 50V; LCSC Part TBD
D9: 1N4148W; D_SOD-123F; LCSC Part C81598
D10, D11: PESD3V3S1BA-N; D_SOD-523; LCSC Part C316037
F6: FUSE 500mA; Fuse_0805_2012Metric; LCSC Part C269104
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J5: DC_Jack; BarrelJack_Horizontal
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J7: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J8: Conn_4-20mA; PhoenixContact_MSTBA_2,5_3-G_1x03_P5.00mm_Horizontal
L11, L12, L13, L14: 600R; L_0603_1608Metric; LCSC Part C1002
LED1: LOAD; LED_0603_1608Metric
LED2: STAT; LED_0603_1608Metric
LED3: VSYNC; LED_0603_1608Metric
LED4: PWR; LED_0603_1608Metric
LED5, LED6, LED7, LED8, LED9, LED10: JE2835AWT; LED-SMD_L3.3-W2.8-RD; LCSC Part TBD
Q3, Q4, Q5: S9013J3; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C6749
Q6: SS8050; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C2150
R42, R43, R44: 330; R_0603_1608Metric; LCSC Part TBD
R45: 0; R_0603_1608Metric; LCSC Part TBD
R46: 0R; R_0603_1608Metric; LCSC Part TBD
R47, R48, R49: 47k; R_0402_1005Metric; LCSC Part TBD
R50, R56, R57: 1k; R_0402_1005Metric; LCSC Part TBD
R51: 220; R_0603_1608Metric; LCSC Part TBD
R52, R59, R61: 10k; R_0402_1005Metric; LCSC Part TBD
R53, R54, R55: 22k; R_0402_1005Metric; LCSC Part TBD
R58: 4.7k; R_0402_1005Metric; LCSC Part TBD
R60, R62: 20R; R_0603_1608Metric; Tolerance 1%; LCSC Part TBD
SW1, SW2: BTN-TS-1187A-B-A-B; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL-2; LCSC Part C318884
TV5: SRV05-4-P-T7; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; LCSC Part C85364
U11, U12: BCR421UE6327; SC-74-6_L2.9-W1.6-P0.95-LS2.5-BR; LCSC Part C112923
USB1: Micro; MICRO-USB-SMD_10118194-0001LF; LCSC Part C132563

Connections:
+2V8: LED3.2 (A); also elsewhere on the board
+3.3V: C68.1, C75.2, L11.1, LED1.2 (A), LED2.2 (A), LED4.2 (A), R56.1, SW1.3 (C), SW1.4 (D); also elsewhere on the board
+5V_POE: J7.3; also elsewhere on the board
+12V: C72.1, C74.1, L13.2, L14.2; also elsewhere on the board
+12VA: J8.1; also elsewhere on the board
+12VIN: J5.1; also elsewhere on the board
+12V_POE: J7.4; also elsewhere on the board
/USB,LED,BUZZ,IO,BTB/ID: R46.2, TV5.1, USB1.4 (ID)
BTN_WKUP: R57.1; also elsewhere on the board
DCMI_VSYNC: R49.1; also elsewhere on the board
GND: C68.2, C69.1, C70.2, C71.2, C72.2, C73.2, C74.2, D10.1, D11.2, J5.2, J5.3, J6.1, J6.2, J7.2, L12.2, Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), R51.2, R52.1, R53.1, R54.1, R55.1, R58.1, R59.1, R60.1, R61.1, R62.1, SW2.3 (C), SW2.4 (D), TV5.2, U11.4 (GND), U12.4 (GND), USB1.5 (GND); also elsewhere on the board
GNDA: J8.3; also elsewhere on the board
ISEN: J7.1, J8.2; also elsewhere on the board
LED_LOAD: R47.1; also elsewhere on the board
LED_STAT: R48.1; also elsewhere on the board
NRST: C70.1, D11.1, R56.2, SW2.1 (A), SW2.2 (B); also elsewhere on the board
unnamed: BUZZER1.1 (+), C69.2, D9.1 (K), L11.2
unnamed: BUZZER1.2 (-), R45.1
unnamed: C71.1, L13.1, LED7.2 (A)
unnamed: C73.1, L14.1, LED10.2 (A)
unnamed: C75.1, D10.2, R57.2, R58.2, SW1.1 (A), SW1.2 (B)
unnamed: D9.2 (A), Q6.3 (C), R45.2
unnamed: F6.2, USB1.1 (VBUS)
unnamed: L12.1, USB1.6 (S)
unnamed: LED1.1 (K), R42.1
unnamed: LED2.1 (K), R43.1
unnamed: LED3.1 (K), R44.1
unnamed: LED4.1 (K), R51.1
unnamed: LED5.1 (K), U11.2 (OUT), U11.3 (OUT), U11.5 (OUT)
unnamed: LED5.2 (A), LED6.1 (K)
unnamed: LED6.2 (A), LED7.1 (K)
unnamed: LED8.1 (K), U12.2 (OUT), U12.3 (OUT), U12.5 (OUT)
unnamed: LED8.2 (A), LED9.1 (K)
unnamed: LED9.2 (A), LED10.1 (K)
unnamed: Q3.1 (B), R47.2, R53.2
unnamed: Q3.3 (C), R42.2
unnamed: Q4.1 (B), R48.2, R54.2
unnamed: Q4.3 (C), R43.2
unnamed: Q5.1 (B), R49.2, R55.2
unnamed: Q5.3 (C), R44.2
unnamed: Q6.1 (B), R50.2, R52.2
unnamed: R60.2, U11.6 (Rext)
unnamed: R62.2, U12.6 (Rext)
PA3: R50.1; also elsewhere on the board
PA10: R46.1; also elsewhere on the board
PB14: R59.2, U11.1 (EN); also elsewhere on the board
PB15: R61.2, U12.1 (EN); also elsewhere on the board
USB_D+: TV5.6, USB1.3 (Data+); also elsewhere on the board
USB_D-: TV5.4, USB1.2 (Data-); also elsewhere on the board
VBUS: F6.1, TV5.5; also elsewhere on the board

Notes on the sheet:
90Ω差動走線
BUZZER
Button
Camera Light
Power & FPC
Mounting Hole
LED
USB

Parts:
C26, C27, C37: 100nF; C_0402_1005Metric; Voltage 25V; LCSC Part TBD
C28: 10uF; C_0402_1005Metric; Voltage 6.3V; LCSC Part TBD
C29, C30, C31, C32, C33, C34: 100nF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
C35, C36: 15pF; C_0402_1005Metric; Voltage 16V; LCSC Part TBD
C38, C39: 2.2uF; C_0402_1005Metric; Voltage 6.3V; LCSC Part TBD
C40, C41: 15pF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
CN1: VBAT; CONN-TH_0530470210; LCSC Part C114130
D5: BAT54C; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; LCSC Part C37704
F4, F5: 100mA; Fuse_0603_1608Metric; LCSC Part C883090
J3: FireDAP-SWD; PinHeader_1x05_P2.54mm_Vertical
J4: UART; PinHeader_1x04_P2.54mm_Vertical
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R10: 0R; R_0603_1608Metric; LCSC Part TBD
R11, R12: 10k; R_0402_1005Metric; LCSC Part TBD
R13: 33R; R_0603_1608Metric; LCSC Part TBD
R14, R15, R16, R17, R18: 49.9R; R_0603_1608Metric; LCSC Part TBD
R19, R20: 1k; R_0402_1005Metric; LCSC Part TBD
TV1, TV2: SRV05-4-P-T7; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; LCSC Part C85364
U7: STM32F407VGTx; LQFP-100_14x14mm_P0.5mm; LCSC Part C12345
X1: 32.768k; FC-135R_L3.2-W1.5; LCSC Part C32346
X2: 25M; OSC-SMD_4P-L3.2-W2.5-BL; LCSC Part C9006

Connections:
+3.3V: C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, D5.1 (A), F4.1, F5.2, JP1.2 (B), JP2.2 (B), U7.11 (VDD), U7.19 (VDD), U7.28 (VDD), U7.50 (VDD), U7.75 (VDD), U7.100 (VDD); also elsewhere on the board
+3.3VA: C26.1, U7.22 (VDDA); also elsewhere on the board
/MCU,SWD,UART,BOOT/BT0: JP1.1 (A), R19.1, TV2.3
/MCU,SWD,UART,BOOT/BT1: JP2.1 (A), R20.2, TV2.1
/MCU,SWD,UART,BOOT/SWC: J3.2, R15.1, TV1.3
/MCU,SWD,UART,BOOT/SWD: J3.4, R16.1, TV1.1
/MCU,SWD,UART,BOOT/SWN: J3.1, R14.1, TV1.4
/MCU,SWD,UART,BOOT/SWO: TV1.6
/MCU,SWD,UART,BOOT/SWV: F4.2, J3.5, TV1.5
/MCU,SWD,UART,BOOT/UAR: J4.2, R17.1, TV2.4
/MCU,SWD,UART,BOOT/UAT: J4.3, R18.1, TV2.6
/MCU,SWD,UART,BOOT/UAV: F5.1, J4.1, TV2.5
ADC_20MA: U7.18 (PC3); also elsewhere on the board
BOOT0: R11.1, R19.2, U7.94 (BOOT0)
BOOT1: R12.1, R20.1, U7.37 (PB2)
BTN_TAMP: U7.7 (PC13)
BTN_WKUP: U7.23 (PA0); also elsewhere on the board
DBG_RX: R17.2, U7.56 (PD9)
DBG_TX: R18.2, U7.55 (PD8)
DCMI_D0: U7.63 (PC6); also elsewhere on the board
DCMI_D1: U7.64 (PC7); also elsewhere on the board
DCMI_D2: U7.97 (PE0); also elsewhere on the board
DCMI_D3: U7.98 (PE1); also elsewhere on the board
DCMI_D4: U7.3 (PE4); also elsewhere on the board
DCMI_D5: U7.92 (PB6); also elsewhere on the board
DCMI_D6: U7.4 (PE5); also elsewhere on the board
DCMI_D7: U7.5 (PE6); also elsewhere on the board
DCMI_HSYNC: U7.29 (PA4); also elsewhere on the board
DCMI_PIXCLK: U7.31 (PA6); also elsewhere on the board
DCMI_VSYNC: U7.93 (PB7); also elsewhere on the board
ETH_CLKIN: R13.2; also elsewhere on the board
ETH_CRS_DV: U7.32 (PA7); also elsewhere on the board
ETH_MDC: U7.16 (PC1); also elsewhere on the board
ETH_MDIO: U7.25 (PA2); also elsewhere on the board
ETH_REF_CLK: U7.24 (PA1); also elsewhere on the board
ETH_RXD0: U7.33 (PC4); also elsewhere on the board
ETH_RXD1: U7.34 (PC5); also elsewhere on the board
ETH_TXD0: U7.51 (PB12); also elsewhere on the board
ETH_TXD1: U7.52 (PB13); also elsewhere on the board
ETH_TX_EN: U7.48 (PB11); also elsewhere on the board
GND: C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.1, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, CN1.1, J3.3, J4.4, R11.2, R12.2, TV1.2, TV2.2, U7.10 (VSS), U7.27 (VSS), U7.74 (VSS), U7.99 (VSS), X2.2 (GND), X2.4 (GND); also elsewhere on the board
GNDA: C26.2, C27.2, U7.20 (VSSA); also elsewhere on the board
LED_LOAD: U7.15 (PC0); also elsewhere on the board
LED_STAT: U7.17 (PC2); also elsewhere on the board
MCO1: R13.1, U7.67 (PA8)
MCO2: R10.1, U7.66 (PC9)
NRST: R14.2, U7.14 (NRST); also elsewhere on the board
unnamed: C35.2, U7.8 (PC14), X1.1
unnamed: C36.1, U7.9 (PC15), X1.2
unnamed: C37.1, D5.3 (K), U7.6 (VBAT)
unnamed: C38.1, U7.49 (VCAP_1)
unnamed: C39.1, U7.73 (VCAP_2)
unnamed: C40.1, U7.12 (PH0), X2.1 (OSC1)
unnamed: C41.1, U7.13 (PH1), X2.3 (OSC2)
unnamed: CN1.2, D5.2 (A)
OV_CLKIN: R10.2; also elsewhere on the board
OV_PWDN: U7.1 (PE2); also elsewhere on the board
OV_RESET: U7.2 (PE3); also elsewhere on the board
PA3: U7.26 (PA3); also elsewhere on the board
PA5: U7.30 (PA5)
PA9: U7.68 (PA9)
PA10: U7.69 (PA10); also elsewhere on the board
PA13: R16.2, U7.72 (PA13)
PA14: R15.2, U7.76 (PA14)
PA15: U7.77 (PA15); also elsewhere on the board
PB0: U7.35 (PB0)
PB1: U7.36 (PB1)
PB3: U7.89 (PB3)
PB4: U7.90 (PB4)
PB5: U7.91 (PB5)
PB8: U7.95 (PB8); also elsewhere on the board
PB9: U7.96 (PB9); also elsewhere on the board
PB10: U7.47 (PB10)
PB14: U7.53 (PB14); also elsewhere on the board
PB15: U7.54 (PB15); also elsewhere on the board
PC8: U7.65 (PC8)
PC10: U7.78 (PC10); also elsewhere on the board
PC11: U7.79 (PC11); also elsewhere on the board
PC12: U7.80 (PC12); also elsewhere on the board
PD0: U7.81 (PD0)
PD1: U7.82 (PD1)
PD2: U7.83 (PD2)
PD3: U7.84 (PD3)
PD4: U7.85 (PD4)
PD5: U7.86 (PD5)
PD6: U7.87 (PD6)
PD7: U7.88 (PD7)
PD10: U7.57 (PD10)
PD11: U7.58 (PD11)
PD12: U7.59 (PD12)
PD13: U7.60 (PD13)
PD14: U7.61 (PD14)
PD15: U7.62 (PD15)
PE7: U7.38 (PE7)
PE8: U7.39 (PE8)
PE9: U7.40 (PE9)
PE10: U7.41 (PE10)
PE11: U7.42 (PE11)
PE12: U7.43 (PE12)
PE13: U7.44 (PE13)
PE14: U7.45 (PE14)
PE15: U7.46 (PE15)
USB_D+: U7.71 (PA12); also elsewhere on the board
USB_D-: U7.70 (PA11); also elsewhere on the board
VREF_IN: C27.1, U7.21 (VREF+); also elsewhere on the board

Notes on the sheet:
BOOT & DEBUG
MCU STM32F407VGTx

Parts:
C42, C49: 1uF; C_0603_1608Metric; Voltage 50V; LCSC Part TBD
C43: 10uF; C_0603_1608Metric; Voltage 16V; LCSC Part TBD
C44, C50, C51: 100nF; C_0603_1608Metric; Voltage 50V; LCSC Part TBD
C45: 1uF; C_0402_1005Metric; Voltage 25V; LCSC Part TBD
C46: 100nF; C_0402_1005Metric; Voltage 16V; LCSC Part TBD
C47: 10uF; C_0402_1005Metric; Voltage 6.3V; LCSC Part TBD
C48: 100nF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
C52: 4.7nF; C_0603_1608Metric; Voltage 50V; LCSC Part TBD
CAM1: OV2640_7mm_FPC-05F-24PH20; LCSC Part C2856805
D6: 1N4148W; D_SOD-123F; LCSC Part C81598
D7, D8: PESD3V3S1BA-N; D_SOD-523; LCSC Part C316037
L6, L7: 600R; L_0603_1608Metric; LCSC Part C1002
L8: 100R; L_0805_2012Metric; LCSC Part C1015
R21, R22: 2.2k; R_0402_1005Metric; LCSC Part TBD
R23, R24, R25: 10k; R_0402_1005Metric; LCSC Part TBD
R26: 51R; R_0603_1608Metric; LCSC Part TBD
R27: 100R; R_0603_1608Metric; Tolerance 0.1%; LCSC Part TBD
R28: 5.1k; R_0603_1608Metric; Tolerance 1%; LCSC Part TBD
R29: 10K; RES-ADJ-SMD_3P-L3.0-W3.8-P1.75-BR; LCSC Part C719176
U8: LM358; SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL; LCSC Part C7950
U9: W25Q128JVSIQTR; SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL; LCSC Part C97521

Connections:
+2V5: U8.5 (+); also elsewhere on the board
+2V8: C42.2, C45.2, CAM1.11 (DOVDD), L6.1, R21.1, R22.1, R23.1; also elsewhere on the board
+3.3V: C51.2, R25.1, U9.3 (IO2_~WP), U9.7 (IO3_~RST), U9.8 (VCC); also elsewhere on the board
+5VA: C49.1, C50.2, U8.8 (V+); also elsewhere on the board
+12V: L8.2; also elsewhere on the board
+12VA: L8.1; also elsewhere on the board
/Flash,Camera,4-20mA Receiver/OV_AGND: C43.2, C44.1, CAM1.2 (AGND), L7.2
/Flash,Camera,4-20mA Receiver/OV_AVDD: C43.1, C44.2, CAM1.4 (AVDD), L6.2
/Flash,Camera,4-20mA Receiver/OV_DVDD_1V3: C46.1, C47.1, CAM1.10 (DVDD)
ADC_20MA: C52.2, R26.1; also elsewhere on the board
DCMI_D0: CAM1.19 (D2); also elsewhere on the board
DCMI_D1: CAM1.21 (D3); also elsewhere on the board
DCMI_D2: CAM1.22 (D4); also elsewhere on the board
DCMI_D3: CAM1.20 (D5); also elsewhere on the board
DCMI_D4: CAM1.18 (D6); also elsewhere on the board
DCMI_D5: CAM1.16 (D7); also elsewhere on the board
DCMI_D6: CAM1.14 (D8); also elsewhere on the board
DCMI_D7: CAM1.12 (D9); also elsewhere on the board
DCMI_HSYNC: CAM1.9 (HREF); also elsewhere on the board
DCMI_PIXCLK: CAM1.17 (PCLK); also elsewhere on the board
DCMI_VSYNC: CAM1.7 (VSYNC); also elsewhere on the board
GND: C42.1, C45.1, C46.2, C47.2, C48.1, C51.1, CAM1.15 (DGND), CAM1.25, CAM1.26, L7.1, R24.2, U9.4 (GND); also elsewhere on the board
GNDA: C49.2, C50.1, C52.1, D7.2, D8.1, R27.2, R28.2, U8.4 (V-); also elsewhere on the board
ISEN: D6.2 (A); also elsewhere on the board
unnamed: D6.1 (K), D7.1, R27.1, U8.3 (+)
unnamed: D8.2, R26.2, R29.2, U8.1
unnamed: R28.1, R29.3, U8.2 (-)
OV_CLKIN: CAM1.13 (XCLK); also elsewhere on the board
OV_PWDN: CAM1.8 (PWND), R24.1; also elsewhere on the board
OV_RESET: C48.2, CAM1.6 (~RESET), R23.2; also elsewhere on the board
PA15: R25.2, U9.1 (~CS); also elsewhere on the board
PB8: CAM1.5 (SIOC), R22.2; also elsewhere on the board
PB9: CAM1.3 (SIOD), R21.2; also elsewhere on the board
PC10: U9.6 (CLK); also elsewhere on the board
PC11: U9.2 (DO); also elsewhere on the board
PC12: U9.5 (DI); also elsewhere on the board
VREF_IN: U8.6 (-), U8.7; also elsewhere on the board

Notes on the sheet:
4-20ma Receiver
CAMERA
Flash
50Ω等長走線
