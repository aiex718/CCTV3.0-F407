# Repository aiex718/CCTV3.0-F407 (continued)

## KiCad design PCB/CCTV3_F407_REV200/CCTV3_F407_REV200.kicad_pcb (continued)

Parts:
C1, C8, C12: 100nF; C_0603_1608Metric; Voltage 50V; LCSC Part TBD
C2, C6, C9, C13, C15: 10uF; C_0603_1608Metric; Voltage 25V; LCSC Part TBD
C3, C14: 100uF; CAP-SMD_L3.5-W2.8; Voltage 6.3V Tantalum; LCSC Part TBD
C4, C5: 1uF; C_0603_1608Metric; Voltage 25V; LCSC Part TBD
C7, C25: 220uF; CAP-SMD_BD6.3-L6.6-W6.6-LS7.2-R-RD; Voltage 25V; LCSC Part C371974
C10: 100nF; C_0402_1005Metric; Voltage 16V; LCSC Part TBD
C11, C16: 10uF; C_0402_1005Metric; Voltage 6.3V; LCSC Part TBD
C17: 22nF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
C18, C19: 1uF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
C20, C21: 10uF; C_0402_1005Metric; Voltage 50V; LCSC Part TBD
C22: 1uF; C_0603_1608Metric; Voltage 16V; LCSC Part TBD
C23, C24: 10uF; C_1206_3216Metric; Voltage 50V; LCSC Part TBD
D1: SMAJ5.0CA; D_SMA; LCSC Part C83324
D2: ZMM10; LL-34_L3.5-W1.5-RD; LCSC Part C707201
D3: ZMM5V6; LL-34_L3.5-W1.5-RD; LCSC Part C8062
D4: SS34; D_SMA; LCSC Part C8678
F1, F2, F3: FUSE 0.75A; Fuse_1812_4532Metric; Voltage 33V
J1: Jmp_5V; PinHeader_2x01_P2.54mm_Vertical
J2: Jmp_3.3V; PinHeader_2x01_P2.54mm_Vertical
L1, L4, L5: 100R; L_0805_2012Metric; LCSC Part C1015
L2, L3: 600R; L_0603_1608Metric; LCSC Part C1002
Q1: AO3400A; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; LCSC Part C20917
Q2: AO3401A; SOT-23_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C15127
R1, R7: 4.7k; R_0402_1005Metric; LCSC Part TBD
R2, R4: 4.7k; R_0603_1608Metric; LCSC Part TBD
R3, R8: 6.8k; R_0402_1005Metric; LCSC Part TBD
R5, R6: 47k; R_0603_1608Metric; LCSC Part TBD
R9: 800R; R_0603_1608Metric; LCSC Part TBD
U1: AMS1117-5.0; SOT-223_L6.5-W3.5-P2.30-LS7.0-BR; LCSC Part C6187
U2, U4: MT9700; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; LCSC Part C89855
U3: AMS1117-3.3; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR; LCSC Part C6186
U5: RT9193-28GB; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; LCSC Part C56731
U6: CJ431; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; LCSC Part C3113

Connections:
+2V5: C22.2, R9.1, U6.1 (K), U6.2 (R); also elsewhere on the board
+2V8: C16.1, U5.5 (VOUT); also elsewhere on the board
+3.3V: C10.1, C11.1, C15.1, C20.1, L3.1, U4.1 (VOUT), U5.1 (VIN), U5.3 (EN); also elsewhere on the board
+3.3VA: C21.1, L3.2, R9.2; also elsewhere on the board
+3.3VIN: J2.2, R7.1, U4.5 (VIN)
+5V: C9.1, C12.1, C13.1, C18.1, L2.1, U2.1 (VOUT), U3.3 (VIN)
+5VA: C19.1, L2.2; also elsewhere on the board
+5VIN: C4.1, F2.2, L1.1, Q1.3 (D), Q2.2 (S)
+5V_POE: F2.1; also elsewhere on the board
+12V: C1.1, C2.1, C24.1, C25.1, L4.2, R4.2, U1.1 (GND); also elsewhere on the board
+12VIN: F3.1; also elsewhere on the board
+12V_DC: D4.2 (A), F3.2, R2.2
+12V_POE: F1.1; also elsewhere on the board
/POWER/LDO_3.3V: C14.1, J2.1, U3.2 (VOUT), U3.4 (VOUT)
/POWER/LDO_5V: C3.1, D1.1, Q1.2 (S), U1.2 (VOUT), U1.4 (VOUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C23.2, C24.2, C25.2, D1.2, D2.2 (A), D3.2 (A), L5.1, R3.2, R5.1, R6.1, R8.2, U1.3 (VIN), U2.2 (GND), U3.1 (GND), U4.2 (GND), U5.2 (GND); also elsewhere on the board
GNDA: C18.2, C19.2, C20.2, C21.2, C22.1, L5.2, U6.3 (A); also elsewhere on the board
unnamed: C5.1, J1.1, L1.2
unnamed: C6.1, C7.1, C8.1, J1.2, R1.1, U2.5 (VIN)
unnamed: C17.1, U5.4 (BP)
unnamed: C23.1, D4.1 (K), F1.2, L4.1
unnamed: D2.1 (K), Q1.1 (G), R2.1, R5.2
unnamed: D3.1 (K), Q2.1 (G), R4.1, R6.2
unnamed: R1.2, U2.4 (EN)
unnamed: R3.1, U2.3 (SET)
unnamed: R7.2, U4.4 (EN)
unnamed: R8.1, U4.3 (SET)
VBUS: Q2.3 (D); also elsewhere on the board

Notes on the sheet:
5V Current Limit
2.8V LDO
3.3V 1A
5V LDO
VBUS Switch
VDDA & VREF
3.3V LDO
Ext. Power
5V 1A

Board: 4 copper layers, 70.0 x 80.0 mm, 224 parts (0 on the bottom side), 146 nets.

File PCB/CCTV3_F407_REV200/Assembly/CCTV3_F407_REV200_BOM.csv (part):

"Source:","/Users/aiex718/Private/Workspace/CCTV3.0-F407/PCB/CCTV3_F407_REV200/CCTV3_F407_REV200.kicad_sch"
"Date:","Friday, 25 November 2022 at 01:05:36"
"Tool:","Eeschema (6.0.8-1)-1"
"Generator:","/Applications/KiCad/KiCad.app/Contents/SharedSupport/plugins/bom_csv_grouped_by_value.py"
"Component Count:","224"

"Individual Components:"

"Item","Qty","Reference(s)","Value","LibPart","Footprint","Datasheet","JLC Part","LCSC Part","Load Cap","Manufacturer","Model","Tolerance","Voltage"
"","","BUZZER1","HNB09A03","lcsc_parts:HNB09A03","lcsc_parts:BUZ-TH_BD9.0-P5.00-D0.6-FD","https://lcsc.com/product-detail/Buzzers_buzzerHNB09A03_C96102.html","Extended Part","C96102","","Jiangsu Huaneng Elec","","",""
"","","C1","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C2","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","25V"
"","","C3","100uF","lcsc_parts:Cap_Polarized","lcsc_parts:CAP-SMD_L3.5-W2.8","https://lcsc.com/product-detail/Tantalum-Capacitors_AVX_TAJB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","Basic Part","TBD","","AVX","","","6.3V Tantalum"
"","","C4","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","25V"
"","","C5","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","25V"
"","","C6","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","25V"
"","","C7","220uF","lcsc_parts:Cap_Polarized","lcsc_parts:CAP-SMD_BD6.3-L6.6-W6.6-LS7.2-R-RD","https://lcsc.com/product-detail/Others_Lelon-VZT221M1ETR-060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","Extended Part","C371974","","Lelon","","","25V"
"","","C8","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C9","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","25V"
"","","C10","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","16V"
"","","C11","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C12","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C13","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","25V"
"","","C14","100uF","lcsc_parts:Cap_Polarized","lcsc_parts:CAP-SMD_L3.5-W2.8","https://lcsc.com/product-detail/Tantalum-Capacitors_AVX_TAJB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","Basic Part","TBD","","AVX","","","6.3V Tantalum"
"","","C15","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","25V"
"","","C16","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C17","22nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C18","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C19","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C20","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C21","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C22","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","16V"
"","","C23","10uF","lcsc_parts:Cap","Capacitor_SMD:C_1206_3216Metric","~","","TBD","","","","","50V"
"","","C24","10uF","lcsc_parts:Cap","Capacitor_SMD:C_1206_3216Metric","~","","TBD","","","","","50V"
"","","C25","220uF","lcsc_parts:Cap_Polarized","lcsc_parts:CAP-SMD_BD6.3-L6.6-W6.6-LS7.2-R-RD","https://lcsc.com/product-detail/Others_Lelon-VZT221M1ETR-060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","Extended Part","C371974","","Lelon","","","25V"
"","","C26","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","25V"
"","","C27","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","25V"
"","","C28","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C29","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C30","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C31","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C32","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C33","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C34","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C35","15pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","16V"
"","","C36","15pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","16V"
"","","C37","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","25V"
"","","C38","2.2uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C39","2.2uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C40","15pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C41","15pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C42","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C43","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","16V"
"","","C44","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C45","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","25V"
"","","C46","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","16V"
"","","C47","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C48","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C49","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C50","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C51","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C52","4.7nF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","50V"
"","","C53","1uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","25V"
"","","C54","470pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C55","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C56","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C57","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C58","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C59","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","6.3V"
"","","C60","100nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","16V"
"","","C61","10pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C62","10pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C63","10pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C64","10pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C65","220nF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","16V"
"","","C66","15pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C67","15pF","lcsc_parts:Cap","Capacitor_SMD:C_0402_1005Metric","~","","TBD","","","","","50V"
"","","C68","10uF","lcsc_parts:Cap","Capacitor_SMD:C_0603_1608Metric","~","","TBD","","","","","10V"
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
## KiCad design PCB/CCTV3_F407_REV100/CCTV3_F407_REV100.kicad_pcb

Notes on the sheet:
PAGE_5
PAGE_1
PAGE_2
PAGE_3
${BOARDNAME}
Table of Contents
PAGE_6
PAGE_4

Parts:
C62, C65, C66, C68, C74: 100nF; C0603; Voltage 50V; LCSC Part TBD
C63: 1uF; C0603; Voltage 50V; LCSC Part TBD
C64: 470pF; C0603; Voltage 50V; LCSC Part TBD
C67, C69: 10uF; C0603; Voltage 25V; LCSC Part TBD
C70, C71, C72, C73: 10pF; C0603; Voltage 50V; LCSC Part TBD
C75, C76: 15pF; C0603; Voltage 50V; LCSC Part TBD
L7, L8: 600R; L0603; LCSC Part C1002
LED1, LED2: NC; LED0603-R-RD_WHITE
R31, R32: 270R; R0603; LCSC Part TBD
R33, R34, R35, R40: 10k; R0603; Tolerance 1%; LCSC Part TBD
R36, R37, R38, R39: 49.9R; R0603; LCSC Part TBD
R41: 12.1k; R0603; Tolerance 1%; LCSC Part TBD
R42, R43: 4.7k; R0603; LCSC Part TBD
R44: NC; R0603; LCSC Part TBD
RJ1: HR913550A; RJ45-TH_HR913550A; LCSC Part C163507
TV1: SRV05-4-P-T7; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; LCSC Part C85364
U11: LAN8720A; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
X3: 25M; OSC-SMD_4P-L3.2-W2.5-BL; LCSC Part C9006

Connections:
+3.3V: C62.1, C69.1, L7.2, R33.1, R34.1, R35.1, U11.9 (VDDIO); also elsewhere on the board
/PHY,Ethernet/LINK: LED1.1 (A), R43.2, RJ1.12, U11.3 (LED1/REGOFF)
/PHY,Ethernet/SPD: LED2.1 (A), R42.2, RJ1.9, U11.2 (LED2/nINTSEL)
GND: C62.2, C63.1, C64.1, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.1, C75.2, C76.2, L8.2, R31.2, R32.2, R40.2, R41.1, R42.1, R43.1, RJ1.8 (GND), TV1.2, U11.25 (VSS), X3.2 (GND), X3.4 (GND); also elsewhere on the board
MCO1: R44.1; also elsewhere on the board
NRST: U11.15 (RST); also elsewhere on the board
unnamed: C63.2, C64.2, U11.6 (VDDCR)
unnamed: C75.1, R44.2, U11.5 (XTAL1/CLKIN), X3.1 (OSC1)
unnamed: C76.1, U11.4 (XTAL2), X3.3 (OSC2)
unnamed: L8.1, RJ1.13, RJ1.14
unnamed: LED1.2 (K), R31.1, RJ1.11
unnamed: LED2.2 (K), R32.1, RJ1.10
unnamed: R40.1, U11.10 (RXER/PHYAD0)
unnamed: R41.2, U11.24 (RBIAS)
PA1: U11.14 (INT/REFCLKO); also elsewhere on the board
PA2: U11.12 (MDIO); also elsewhere on the board
PA7: R33.2, U11.11 (CRS_DV/MODE2); also elsewhere on the board
PC1: U11.13 (MDC); also elsewhere on the board
PC4: R35.2, U11.8 (RXD0/MODE0); also elsewhere on the board
PC5: R34.2, U11.7 (RXD1/MODE1); also elsewhere on the board
PG11: U11.16 (TXEN); also elsewhere on the board
PG13: U11.17 (TXD0); also elsewhere on the board
PG14: U11.18 (TXD1); also elsewhere on the board
RXCT: C65.1, C66.1, C67.1, C68.1, C74.2, L7.1, R36.1, R37.1, R38.1, R39.1, RJ1.4, RJ1.5, U11.1 (VDD2A), U11.19 (VDD1A); also elsewhere on the board
RXN: C73.1, R39.2, RJ1.6, TV1.1, U11.22 (RXN); also elsewhere on the board
RXP: C72.1, R38.2, RJ1.3, TV1.3, U11.23 (RXP); also elsewhere on the board
TXN: C71.1, R37.2, RJ1.2, TV1.4, U11.20 (TXN); also elsewhere on the board
TXP: C70.1, R36.2, RJ1.1, TV1.6, U11.21 (TXP); also elsewhere on the board

Notes on the sheet:
Ethernet Phy
100Ω差動走線
50Ω等長走線

Parts:
BUZZER1: HNB09A05; BUZ-TH_BD9.6-P5.00-D0.7-FD; LCSC Part C96493
C77, C82: 100nF; C0603; Voltage 50V; LCSC Part TBD
C78, C79, C80, C81: 10uF; C1206; Voltage 50V; LCSC Part TBD
D6: 1N4148W; SOD-123F_L2.7-W1.6-LS3.8-RD; LCSC Part C81598
D7, D8: PESD3V3S1BA-N; SOD-523_L1.2-W0.8-LS1.6-BI; LCSC Part C316037
F4: 750mA; F1812; LCSC Part C151170
FPC1: FPC-05F-20PH15; FPC-SMD_20P-P0.50_XUNPU_FPC-05F-20PH15; LCSC Part C2856820
J8: DC_Jack; BarrelJack_Horizontal
L10, L11, L12: 600R; L0603; LCSC Part C1002
LED3, LED4, LED5, LED6: 0603; LED0603-R-RD_WHITE; LCSC Part TBD
LED7, LED8, LED9, LED10, LED11, LED12: JE2835AWT; LED-SMD_L3.3-W2.8-RD; LCSC Part TBD
Q3, Q4, Q5: S9013J3; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C6749
Q6: SS8050; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C2150
R45, R46, R47, R54: 330; R0603; LCSC Part TBD
R48: 0; R0603; LCSC Part TBD
R49, R59: 0R; R0603; LCSC Part TBD
R50, R51, R52: 47k; R0603; LCSC Part TBD
R53, R60, R61: 1k; R0603; LCSC Part TBD
R55, R56, R57: 22k; R0603; LCSC Part TBD
R58, R63, R65: 10k; R0603; LCSC Part TBD
R62: 4.7k; R0603; LCSC Part TBD
R64, R66: 20R; R0603; Tolerance 1%; LCSC Part TBD
SW1, SW2: BTN-TS-1187A-B-A-B; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL-2; LCSC Part C318884
TV2: SRV05-4-P-T7; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; LCSC Part C85364
U12, U13: BCR421UE6327; SC-74-6_L2.9-W1.6-P0.95-LS2.5-BR; LCSC Part C112923
USB1: Micro; MICRO-USB-SMD_10118194-0001LF; LCSC Part C132563

Connections:
+2V8: LED5.1 (A); also elsewhere on the board
+3.3V: C82.2, LED3.1 (A), LED4.1 (A), R60.1, SW1.3 (C), SW1.4 (D); also elsewhere on the board
/USB,LED,BUZZ,IO,BTB/ID: R49.2, TV2.1, USB1.4 (ID)
/USB,LED,BUZZ,IO,BTB/VSYNC: R52.1
GND: C77.2, C78.2, C79.2, C80.2, C81.2, D7.1, D8.2, FPC1.1, FPC1.4, FPC1.7, FPC1.10, FPC1.15, FPC1.20, FPC1.21, FPC1.22, J8.2, J8.3, L10.2, Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), R54.2, R55.1, R56.1, R57.1, R58.1, R59.1, R62.1, R63.1, R64.1, R65.1, R66.1, SW2.3 (C), SW2.4 (D), TV2.2, U12.4 (GND), U13.4 (GND), USB1.5 (GND); also elsewhere on the board
NRST: C77.1, D8.1, R60.2, SW2.1 (A), SW2.2 (B); also elsewhere on the board
unnamed: BUZZER1.2, R48.1
unnamed: C78.1, L11.1, LED9.2 (A)
unnamed: C80.1, L12.1, LED12.2 (A)
unnamed: C82.1, D7.2, R61.2, R62.2, SW1.1 (A), SW1.2 (B)
unnamed: D6.2 (A), Q6.3 (C), R48.2
unnamed: F4.2, USB1.1 (VBUS)
unnamed: L10.1, USB1.6 (S)
unnamed: LED3.2 (K), R45.1
unnamed: LED4.2 (K), R46.1
unnamed: LED5.2 (K), R47.1
unnamed: LED6.2 (K), R54.1
unnamed: LED7.1 (K), U12.2 (OUT), U12.3 (OUT), U12.5 (OUT)
unnamed: LED7.2 (A), LED8.1 (K)
unnamed: LED8.2 (A), LED9.1 (K)
unnamed: LED10.1 (K), U13.2 (OUT), U13.3 (OUT), U13.5 (OUT)
unnamed: LED10.2 (A), LED11.1 (K)
unnamed: LED11.2 (A), LED12.1 (K)
unnamed: Q3.1 (B), R50.2, R55.2
unnamed: Q3.3 (C), R45.2
unnamed: Q4.1 (B), R51.2, R56.2
unnamed: Q4.3 (C), R46.2
unnamed: Q5.1 (B), R52.2, R57.2
unnamed: Q5.3 (C), R47.2
unnamed: Q6.1 (B), R53.2, R58.2
unnamed: R59.2, TV2.3
unnamed: R64.2, U12.6 (Rext)
unnamed: R66.2, U13.6 (Rext)
PA0: R61.1; also elsewhere on the board
PA10: R49.1; also elsewhere on the board
PA11: TV2.6, USB1.2 (Data-); also elsewhere on the board
PA12: TV2.4, USB1.3 (Data+); also elsewhere on the board
PF6: R53.1; also elsewhere on the board
PF7: R63.2, U12.1 (EN); also elsewhere on the board
PF8: R65.2, U13.1 (EN); also elsewhere on the board
PF11: R50.1; also elsewhere on the board
PG15: R51.1; also elsewhere on the board
RXCT: FPC1.8, FPC1.9; also elsewhere on the board
RXN: FPC1.6; also elsewhere on the board
RXP: FPC1.5; also elsewhere on the board
TXN: FPC1.3; also elsewhere on the board
TXP: FPC1.2; also elsewhere on the board
VBUS: F4.1, TV2.5; also elsewhere on the board

Notes on the sheet:
90Ω差動走線
BUZZER
Button
Camera Light
Power & FPC
LED
USB
